# IAR project Template.ewp, settings and files
configuration Template (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411VE ST STM32F411VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_ASSERT; USE_HAL_DRIVER; STM32F411xE; LOS_STM32F411RE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\LiteOS\kernel\include; ..\LiteOS\kernel\base\include; ..\LiteOS\kernel\config; ..\LiteOS\kernel\cmsis; ..\LiteOS\kernel\cpu\arm\cortex-m4; ..\LiteOS\kernel\link\iar; ..\example\include; ..\platform\STM32F411RE-NUCLEO; ..\platform; ..\Drivers\BSP\STM32F4xx-Nucleo; ..\Drivers\BSP\STM32F411VE-XF; ..\APP; ..\APP\user_app; ..\APP\misc; ..\Drivers\SENSOR; ..\Drivers\BSP\NBxxModule; ..\APP\misc\USMART
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/example
    ../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_fs.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_api_xmodem.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group Application/misc
    ../APP/misc/: algorithm.c crc16.c crc32.c crc7.c device_protocol.c switch_control.c xor.c
    ../Drivers/BSP/STM32F411VE-XF/: delay.c
    ../APP/misc/USMART/: usmart.c usmart_config.c usmart_str.c
  group Application/User
    ../APP/user_app/: App_debug.c App_NB_control.c App_switch_control.c
    ../APP/: includes.h
    ../user/: main.c
  group drivers/bsp
    ../Drivers/BSP/STM32F411VE-XF/: adc_driver.c bsp_gpio.c demo_xx_driver.c gpio_74hc595_driver.c gpio_beep_driver.c gpio_iic_driver.c gpio_leds_driver.c gpio_matrix_driver.c gpio_powctrl_driver.c gpio_userkey_driver.c oled_driver.c sensor_hall_driver.c sensor_light5537_driver.c spi.c spi1_wsn2_driver.c spi2_rfid2_driver.c spi3_stc_driver.c spi4_wsn1_driver.c spi5_rfid1_driver.c usart6.c usart_debug_driver.c usart_nb_iot_driver.c usart_serialscreen_driver.c
    ../platform/STM32F411RE-NUCLEO/: los_bsp_key.c los_bsp_led.c
    ../Drivers/SENSOR/: sensor_single_line.c
    ../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group drivers/NB
    ../Drivers/BSP/NBxxModule/: NB_BC95.c NB_Board.c NB_Board_Cfg.c timer_user_poll.c
  group drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_wwdg.c
    ../Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c
  group LiteOS/cmsis
    ../LiteOS/kernel/cmsis/: cmsis_liteos.c
  group LiteOS/config
    ../LiteOS/kernel/config/: los_config.c
  group LiteOS/cpu/m4
    ../LiteOS/kernel/cpu/arm/cortex-m4/: los_dispatch_iar.s los_hw.c los_hw_tick.c los_hwi.c
  group LiteOS/kernel
    ../LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../LiteOS/kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../LiteOS/kernel/base/misc/: los_misc.c
    ../LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group LiteOS/platform/stm32f411re
    ../platform/STM32F411RE-NUCLEO/: los_bsp_adapter.c
  group LiteOS/platform/stm32f411re/startup
    ../platform/STM32F411RE-NUCLEO/: los_startup_iar.s
